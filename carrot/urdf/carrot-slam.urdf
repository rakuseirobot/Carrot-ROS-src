Commit message: #update

File: carrot/urdf/carrot-slam.urdf (robot description, URDF)
Before this commit: robot carrot-slam, 3 links, 2 joints
Joints:
- joint horizontal_laser_link_joint: origin xyz=-0.43 0 0.16 -> xyz=0.43 0 0.16 rpy=0 0 3.1415926
